# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;board;board\CubeMX_Config\Inc;libraries\Board_Drivers;libraries\Board_Drivers\lcd;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;applications\nes;applications\nes\inc;applications\nes\port;rt-thread\components\libc\posix\delay;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\posix\pthreads;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/Board_Drivers/: drv_filesystem.c
    libraries/Board_Drivers/lcd/: drv_lcd.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_pwm.c drv_sdio.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group nes
    applications/nes/src/: nes_rom.c nes_ppu.c nes_cpu.c nes.c nes_apu.c nes_mapper.c
    applications/nes/port/: rt_key_scan.c nes_port.c
    applications/nes/src/nes_mapper/: nes_mapper2.c nes_mapper0.c nes_mapper3.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
    rt-thread/components/libc/posix/io/stdio/: libc.c
    rt-thread/components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
