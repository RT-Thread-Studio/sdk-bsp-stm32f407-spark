# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;..\..\rt-thread\components\libc\compilers\common\include;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\rt-thread\components\drivers\wlan;board;board\CubeMX_Config\Inc;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\CMSIS\Include;..\..\libraries\HAL_Drivers\drv_flash;..\..\rt-thread\components\fal\inc;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\rt-thread\components\dfs\filesystems\romfs;..\..\rt-thread\components\finsh;.;..\..\rt-thread\include;..\..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include;..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\rt-thread\components\net\lwip\port;packages\mbedtls-v2.7.10.2\mbedtls\include;packages\mbedtls-v2.7.10.2\ports\inc;packages\netutils-v1.3.3\ntp;packages\netutils-v1.3.3\tftp;.;packages\optparse-v1.0.0;..\..\rt-thread\components\libc\posix\io\poll;..\..\rt-thread\components\libc\posix\io\stdio;..\..\rt-thread\components\libc\posix\ipc;packages\rw007-v2.0.1;packages\rw007-v2.0.1\inc;..\..\rt-thread\components\net\netdev\include;..\..\rt-thread\components\net\sal\include;..\..\rt-thread\components\net\sal\include\socket;..\..\rt-thread\components\net\sal\impl;..\..\rt-thread\components\net\sal\include\dfs_net;..\..\rt-thread\components\net\sal\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Fal
    ../../rt-thread/components/fal/src/: fal_rtt.c fal_flash.c fal.c fal_partition.c
    ../../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    ../../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mbedtls
    packages/mbedtls-v2.7.10.2/mbedtls/library/: timing.c ctr_drbg.c entropy.c pkcs12.c ecdh.c ssl_cookie.c arc4.c x509write_crt.c cipher_wrap.c ssl_ciphersuites.c pem.c threading.c rsa.c entropy_poll.c asn1write.c dhm.c aesni.c bignum.c x509_crl.c pk.c pkwrite.c ssl_cache.c padlock.c x509_create.c md4.c pkparse.c pkcs5.c pk_wrap.c gcm.c pkcs11.c debug.c md.c oid.c ssl_cli.c sha1.c error.c md5.c des.c ssl_srv.c version.c platform.c ecp_curves.c x509_crt.c x509_csr.c sha512.c x509.c blowfish.c version_features.c cmac.c ecp.c x509write_csr.c md2.c ssl_tls.c xtea.c cipher.c md_wrap.c havege.c aes.c ecjpake.c memory_buffer_alloc.c asn1parse.c ssl_ticket.c camellia.c base64.c ripemd160.c hmac_drbg.c ccm.c sha256.c certs.c ecdsa.c rsa_internal.c
    packages/mbedtls-v2.7.10.2/ports/src/: timing_alt.c tls_net.c sha256_alt.c tls_hardware.c sha1_alt.c md5_alt.c tls_certificate.c aes_alt.c arc4_alt.c des_alt.c sha512_alt.c rsa_alt.c tls_client.c
    packages/mbedtls-v2.7.10.2/samples/: tls_app_test.c
  group NetUtils
    packages/netutils-v1.3.3/iperf/: iperf.c
    packages/netutils-v1.3.3/netio/: netio.c
    packages/netutils-v1.3.3/ntp/: ntp.c
    packages/netutils-v1.3.3/tcpdump/: tcpdump.c
    packages/netutils-v1.3.3/telnet/: telnet.c
    packages/netutils-v1.3.3/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group optparse
    packages/optparse-v1.0.0/: optparse.c
  group POSIX
    ../../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.0.1/example/: rw007_stm32_port.c
    packages/rw007-v2.0.1/src/: spi_wifi_rw007.c
  group SAL
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal/src/: sal_socket.c
