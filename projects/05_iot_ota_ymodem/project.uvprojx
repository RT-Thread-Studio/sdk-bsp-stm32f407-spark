# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;board;board\CubeMX_Config\Inc;libraries\Board_Drivers;libraries\Board_Drivers\fal;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;libraries\HAL_Drivers\drv_flash;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\ota_downloader-v1.0.0;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/Board_Drivers/: drv_filesystem.c spi_flash_init.c
    libraries/Board_Drivers/fal/: fal_spi_flash_sfud_port.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal_flash.c fal_rtt.c fal.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ota_downloader
    packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group Utilities
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
