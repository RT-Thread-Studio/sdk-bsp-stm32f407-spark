# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;board;board\CubeMX_Config\Inc;libraries\Board_Drivers;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\finsh;.;rt-thread\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip\port;packages\micropython-v1.13.0;packages\micropython-v1.13.0\port;packages\micropython-v1.13.0\port\modules;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\rw007-v2.0.1;packages\rw007-v2.0.1\inc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group MicroPython
    packages/micropython-v1.13.0/py/: persistentcode.c objfloat.c modio.c objstringio.c reader.c emitnative.c pystack.c vstr.c objsingleton.c objint_longlong.c objfun.c emitnx64.c modmicropython.c nlrsetjmp.c unicode.c objobject.c runtime.c emitbc.c objgetitemiter.c modcmath.c nlrthumb.c objarray.c objslice.c nlrx86.c objnone.c emitcommon.c nlr.c mpz.c scheduler.c stackctrl.c emitnthumb.c moduerrno.c malloc.c modstruct.c binary.c asmarm.c modbuiltins.c objbool.c sequence.c opmethods.c builtinevex.c objproperty.c warning.c pairheap.c asmx64.c modthread.c smallint.c map.c objset.c bc.c nlrpowerpc.c parse.c parsenum.c profile.c objcell.c nlrxtensa.c asmthumb.c emitnxtensa.c mpprint.c argcheck.c objdict.c objzip.c stream.c emitinlinethumb.c objcomplex.c objmap.c emitnarm.c asmbase.c objboundmeth.c gc.c modmath.c repl.c objint.c objlist.c modcollections.c scope.c objreversed.c emitnx86.c objtype.c vm.c parsenumbase.c objclosure.c objmodule.c runtime_utils.c compile.c asmx86.c objattrtuple.c objstr.c ringbuf.c mpstate.c showbc.c asmxtensa.c objenumerate.c lexer.c modsys.c objnamedtuple.c emitinlinextensa.c nlrx64.c emitnxtensawin.c nativeglue.c builtinhelp.c formatfloat.c objpolyiter.c builtinimport.c obj.c objdeque.c qstr.c objint_mpz.c objtuple.c objstrunicode.c modarray.c objfilter.c objrange.c objgenerator.c objexcept.c frozenmod.c modgc.c emitglue.c
    packages/micropython-v1.13.0/extmod/: modbtree.c moduheapq.c machine_pulse.c moducryptolib.c modubinascii.c machine_spi.c modwebrepl.c machine_pinbase.c modussl_mbedtls.c machine_mem.c moduhashlib.c vfs_reader.c vfs_posix_file.c modurandom.c modframebuf.c uos_dupterm.c vfs_fat_file.c modussl_axtls.c vfs.c vfs_fat_diskio.c modonewire.c moduzlib.c machine_signal.c modure.c modwebsocket.c machine_i2c.c vfs_fat.c modutimeq.c utime_mphal.c moduselect.c virtpin.c moduwebsocket.c vfs_posix.c modujson.c moductypes.c
    packages/micropython-v1.13.0/port/modules/: modutime.c modfile.c modutils.c modpyb.c modffi.c moduos.c moduos_file.c modrtthread.c modusocket.c modnetwork.c modnetwork_wlan.c
    packages/micropython-v1.13.0/port/modules/machine/: machine_rtc.c machine_uart.c machine_adc.c machine_wdt.c modmachine.c machine_hw_spi.c machine_timer.c machine_pwm.c machine_hw_i2c.c machine_pin.c machine_lcd.c
    packages/micropython-v1.13.0/lib/utils/: printf.c pyexec.c mpirq.c sys_stdio_mphal.c interrupt_char.c stdout_helpers.c
    packages/micropython-v1.13.0/port/: mpthreadport.c frozen_mpy.c mphalport.c mpy_main.c gccollect.c mpputsnport.c mpgetcharport.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group rw007
    packages/rw007-v2.0.1/example/: rw007_stm32_port.c
    packages/rw007-v2.0.1/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c
    rt-thread/components/net/sal/src/: sal_socket.c
